Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-13T14:11:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 13 14:11:21 2023 * Host: RENSON-PCuyzIdp * Database: C:\Users\naniw\AppData\Local\Temp\2d2cdb2f-2b05-4528-82d4-e2ef0707fead\e9ca3728-14a7-48a9-9a8f-ed4b72d0fb7b\ifc * Database version: 5507 * Database creation date: Mon Mar 13 14:11:21 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 13 14:11:21 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 13 14:11:21 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_350629 | SINK
Port_350629 | SOURCE

# IfcFlowController: healthconnector - slave_renson_d 125, Renson_healthconnector:healthconnector - slave_renson_d 125:350629
In: Level 1
Type - PredefinedType: CONSTANTFLOW; Classification: 57.10.90.7 (Uniformat); Material: RSen_n6_EPP_black
Pset_DistributionFlowElementCommon - Reference: healthconnector - slave_renson_d 125; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_ProductRequirements - Category: Duct Accessories
